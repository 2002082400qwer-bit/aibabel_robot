# Keil uVision project robot.uvprojx, settings and files
target FT32F103 (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: FT32F103VC FMD
  pack: FMD.FT32F1xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x0003F000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: robot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __USE_MATH
  c include: USER/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\robot_calibration.sct
  group USER
    ./USER/Sourse/: FT32F10x_it.c main.c i2c.c delay.c iap.c sys.c pwm.c spi.c tmf8806.c tmf8806_image.c tmf8806_app.c tmf8806_shim.c tof.c uart.c ultrasonic.c adc.c com.c cs1237.c touch.c thermohygro.c mot1.c mot2.c mot3.c motor.c flash.c
software components: CMSIS:CORE 5.5.0, Device:GPIO 1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 1.0.0, Device:StdPeriph Drivers:DMA 1.0.0, Device:StdPeriph Drivers:EXTI 1.0.0, Device:StdPeriph Drivers:FSMC 1.0.0, Device:StdPeriph Drivers:Flash 1.0.0, Device:StdPeriph Drivers:Framework 1.0.0, Device:StdPeriph Drivers:GPIO 1.0.0, Device:StdPeriph Drivers:I2C 1.0.0, Device:StdPeriph Drivers:IWDG 1.0.0, Device:StdPeriph Drivers:PWR 1.0.0, Device:StdPeriph Drivers:RCC 1.0.0, Device:StdPeriph Drivers:RTC 1.0.0, Device:StdPeriph Drivers:SPI 1.0.0, Device:StdPeriph Drivers:TIM 1.0.0, Device:StdPeriph Drivers:USART 1.0.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDIN 1.2.0
